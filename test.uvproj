# Keil uVision project test.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TM4C1231H6PM Texas Instruments
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M4") FPU2
  output: test
  c flags: Optim=1 OneElfS=1
  c define: rvmdk PART_TM4C123GH6PM TARGET_IS_BLIZZARD_RB1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: startup_TM4C123.s system_TM4C123.c source.c
    ./driverlib/rvmdk/: driverlib.lib
